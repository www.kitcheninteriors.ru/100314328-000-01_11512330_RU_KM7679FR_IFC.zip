Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-04-13T07:26:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 13 07:26:25 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{2A82F490-7E8B-4FBE-A37C-3C0833C65980}\ifc * Database version: 5507 * Database creation date: Tue Apr 13 07:26:24 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 13 07:26:25 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 13 07:26:25 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26767900_RU_11512330_KM7679FR, 11512330_RU_KM7679FR:26767900_RU_11512330_KM7679FR:207674
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black, z_Miele_Design_Stainless Steel
Pset_BuildingElementProxyCommon - Reference: 26767900_RU_11512330_KM7679FR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
